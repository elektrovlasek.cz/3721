Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2019-04-17T10:57:30
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Apr 17 10:57:30 2019 * Host: DEGTL09122 * Database: C:\Users\deschvi\AppData\Local\Temp\{B4829731-E91E-43CE-968E-110FA43024D6}\ifc * Database version: 5507 * Database creation date: Wed Apr 17 10:57:28 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Apr 17 10:57:29 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Apr 17 10:57:29 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 26768470_D_11145160_KM7684FL, 11145160_D_KM7684FL:26768470_D_11145160_KM7684FL:205987
In: Level 1
Type - Classification: A-KM-7000 (Uniformat); Material: z_Miele_Design_CLST, z_Miele_Connection_Electric, z_Miele_Design_Glass Black, Default
Pset_BuildingElementProxyCommon - Reference: 26768470_D_11145160_KM7684FL
Pset_ManufacturerTypeInformation - Manufacturer: Miele
